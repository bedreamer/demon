# Keil uVision project demon.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: demon +hex
  c flags: Optimize=8 SizeSpeed=1
  group include
    ../source/include/: STC12C5A60S2.h config.h stdafx.h cmd.h vars.h
  group main
    ../source/main/: demon.c stdafx.c
  group sub
    ../source/main/: vars.c
    ../source/sub/: cmd.c isr.c
